# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER, AT_START_F415_V1_0,__TARGET_FPU_SOFTVFP
  c include: ..\..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\LED_Toggle;..\..\..\..\..\AT32_Board;..\..\..\..\..\..\Middlewares\UCOSIII\uC-CPU;..\..\..\..\..\..\Middlewares\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\..\Middlewares\UCOSIII\uC-LIB;..\..\..\..\..\..\Middlewares\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\..\..\Middlewares\UCOSIII\uCOS-III\Source;..\..\..\..\..\..\Middlewares\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\..\Middlewares\UCOSIII\EvalBoards\BSP;..\..\..\..\..\..\Middlewares\UCOSIII\EvalBoards\uCOS-III;..\..\..\..\..\..\Libraries\driver;..\4G;..\charge_pro;..\common;..\dwin;..\rc522;..\w25qxx;..\dl654;..\HMAC;..\BLE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415cbt7.s
  group AT32Periph
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c at32f4xx_i2c.c at32f4xx_flash.c at32f4xx_spi.c at32f4xx_adc.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_pwr.c at32f4xx_tim.c at32f4xx_iwdg.c
  group BSP
    ../../../../../AT32_Board/: at32_board.c
  group README
    ../: readme.txt
  group UCOS_Port
    ../../../../../../Middlewares/UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS_LIB
    ../../../../../../Middlewares/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
    ../../../../../../Middlewares/UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOS_Source
    ../../../../../../Middlewares/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_CPU
    ../../../../../../Middlewares/UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../../../../../Middlewares/UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group UCOS_Bsp
    ../../../../../../Middlewares/UCOSIII/EvalBoards/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group DRIVER
    ../../../../../../Libraries/driver/: uart1.c uart2.c 485_1.c delay.c device.c HLW8112-SPI.c timer.c adc.c ertc.c uart3.c
    ../../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_exti.c
  group charge_pro
    ../charge_pro/: ch_port.c chproc.c chtask.c cp.c
  group common
    ../common/: mq_service.c
  group 4G
    ../4G/: 4GMain.c 4GRecv.c 4GSend.c ModuleA7680C.c ZFFrame.c Frame66.c Frame66.h
  group rc522
    ../rc522/: read_nuid.c
    ../../../../../../Libraries/driver/: rc522.c
  group w25qxx
    ../w25qxx/: flashdispos.c
    ../../../../../../Libraries/driver/: spi_flash.c
  group dwin
    ../dwin/: Dispkey.c DispkeyFunction.c DispShowStatus.c dwin_com_pro.c DwinProtocol.c MenuDisp .c
  group dl645
    ../dl654/: dlt645_port.c
  group HMAC
    ../HMAC/: utils_hmac.c utils_hmac.h utils_md5.c utils_md5.h utils_sha1.c utils_sha1.h
  group BLE
    ../BLE/: BLELink.c
